## sdkconfig.defaults
```kconfig
CONFIG_UBRIDGE_UART_PORT_NUM=1
CONFIG_UBRIDGE_UART_BAUD_RATE=115200
CONFIG_UBRIDGE_UART_RXD=1
CONFIG_UBRIDGE_UART_TXD=0
```
